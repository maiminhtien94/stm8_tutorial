# IAR project gpio.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\STM8S_StdPeriph_Driver\inc; ..\User; ..\Utilities
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: gpio.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    ../STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c
  group User
    ../User/: main.c stm8s_it.c
  group Utilities
    ../Utilities/: stm8s_clock.c
